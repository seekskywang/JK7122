# Keil uVision project LY-STM32.uvprojx, settings and files
target LY-STM32 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LY-STM32 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o update\7122XCYupdate.bin output\LY-STM32.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Lib\inc;.\System;.\USR;.\HARDWARE;.\HARDWARE
  asm include: .\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group USR
    ./USR/: main.c pbdata.c stm32f10x_it.c user.c test.c Debug.c
    ./HARDWARE/: dma.c
  group Lib
    ./Lib/SRC/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dac.c stm32f10x_adc.c stm32f10x_i2c.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_dma.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c sys.c
  group HARDWARE
    ./HARDWARE/: 24C256.C ADC.C DAC.C GPIO.C TIME.C UART.C Lcd2002.c Disp.c flash_eerom.c Hardware.c Beep.c myiic.c exti.c
    ./: keyboard.c
software components: CMSIS:CORE 5.0.1
